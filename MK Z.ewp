# IAR project MK Z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: startup\; src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MK Z_Debug.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\Konstantin\Desktop\Темы\DigitalMoevs\project DigitalMoevs\MK Z\1986VE9xT\linker\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CAN queue
    src/: canFrameQueue.c canmonitorText.c dataQueue.c linkedList.c
  group control
    src/: angleSensor.c canGkControl.c dus.c dusCalibration.c dusFilter.c engineControl.c gkControlMode.c pidFilter.c pidRegulator.c
  group loader
    src/: loaders.c selfLoader.c
  group lowlevel
    src/: adc.c can.c dac.c flash1986ve9x.c timers.c
  group src
    src/: canmonitor.c canterminal.c debugingInfo.c flashUserData.c global.c SystemInit.c
  group startup
    startup/: define_type.h MDR32Fx.h startup_MDR32F9Qx.s
